# Keil uVision project GPIO_BEEP.uvproj, settings and files
target DebugInRAM (ARM-ADS)
  device: LPC1752 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: GPIO_BEEP
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group CMSIS Files
    ./CM3/: core_cm3.c core_cm3.h
    ./LPC17xx/: system_LPC17xx.c
    ./LPC17xx/Startup/: startup_LPC17xx.s
  group User Code
    ./USER_CODE/: app.c
  group cpu
    ./USER_CODE/cpu/: cpu.c cpu.h cpu.s cpuType.h
  group twkOS
    ./USER_CODE/twkOS/: TwkOS.c TwkOS.h TwkOSconfig.h TwkOStype.h TwkOSutil.h TwkOSutil.c FPFTCBlistArb.c RRTCBarb.c FPFTCBlistArb.h RRTCBarb.h TcbList.c TcbList.h
  group cpuImp
    ./USER_CODE/cpuImp/: cpuImp.c cpuImp.h cpuImpType.h
  group lib
    ./USER_CODE/lib/: TwkIO.c TwkIO.h TwkLib.c TwkLib.h TwkLPC1768.c TwkLPC1768.h TwkSqQueue.c TwkSqQueue.h
target ReleasInFlash (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: GPIO_BEEP +hex
  c flags: Optim=1
  c include: .\LPC17xx;.\USER_CODE\cpu;.\USER_CODE\twkOS;.\USER_CODE\lib;.\USER_CODE\cpuImp
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
